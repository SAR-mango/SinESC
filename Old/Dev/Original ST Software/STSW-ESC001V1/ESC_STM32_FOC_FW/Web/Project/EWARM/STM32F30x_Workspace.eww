<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F30x_MC Library.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UserProject\STM32F30x_UserProject.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>workspace_rebuild_STM32303C_DUAL</name>
      <member>
        <project>STM32F30x_MC Library</project>
        <configuration>STM32F303_DUAL_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F30x_PFC_Project</project>
        <configuration>RELEASE</configuration>
      </member>
      <member>
        <project>STM32F30x_UserProject</project>
        <configuration>STM32303C-EVAL_DUALDRIVE</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>workspace_rebuild_STM32303C_SINGLE</name>
      <member>
        <project>STM32F30x_MC Library</project>
        <configuration>STM32F303_SINGLE_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F30x_PFC_Project</project>
        <configuration>RELEASE</configuration>
      </member>
      <member>
        <project>STM32F30x_UserProject</project>
        <configuration>STM32303C-EVAL_SINGLEDRIVE</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>workspace_rebuild_STM32F302_SINGLE</name>
      <member>
        <project>STM32F30x_MC Library</project>
        <configuration>STM32F302_SINGLE_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F30x_UserProject</project>
        <configuration>STM32F302_SINGLEDRIVE</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>workspace_rebuild_P-NUCLEO-IHM001_SINGLE</name>
      <member>
        <project>STM32F30x_MC Library</project>
        <configuration>STM32F302x8_SINGLE_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F30x_UserProject</project>
        <configuration>P-NUCLEO-IHM001_SINGLEDRIVE</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


