<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\SinESC_Wing_1.0A.ewp</path>
	</project>
	<batchBuild />
</workspace>